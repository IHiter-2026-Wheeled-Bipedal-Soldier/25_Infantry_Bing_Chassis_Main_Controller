# Keil uVision project Project.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: ..\STM32\Driver\CMSIS;..\User;..\STM32\Driver\FWLib;..\STM32\Driver\FWLib\inc;..\STM32\BSP;..\General;..\Communication;..\FreeRTOS\inc;..\FreeRTOS\port\inc;..\Global;..\Other;..\Application\Chassis;..\Application\Gimbal;..\Application\Shooter;..\API;..\OtherTask
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Global
    ../Global/: GlobalDeclare_General.c GlobalDeclare_General.h GlobalDeclare_Chassis.c GlobalDeclare_Chassis.h GlobalDeclare_Gimbal.c GlobalDeclare_Gimbal.h GlobalDeclare_Shooter.c GlobalDeclare_Shooter.h
  group API
    ../API/: Algorithm.c Algorithm.h Algorithm_Simple.c Algorithm_Simple.h General_AuxiliaryFunc.c General_AuxiliaryFunc.h
  group Chassis
    ../Application/Chassis/: Chassis_Task.c Chassis_Task.h Chassis_Stratgy.c Chassis_Stratgy.h Chassis_APIFunction.c Chassis_APIFunction.h
  group Gimbal
    ../Application/Gimbal/: Gimbal_Task.c Gimbal_Task.h Gimbal_Stratgy.c Gimbal_Stratgy.h Gimbal_APIFunction.c Gimbal_APIFunction.h
  group Shooter
    ../Application/Shooter/: Shooter_Task.c Shooter_Task.h Shooter_Stratgy.c Shooter_Stratgy.h Shooter_APIFunction.c Shooter_APIFunction.h
  group OtherTask
    ../OtherTask/: DebugTask.c DebugTask.h ReceiverTask.c ReceiverTask.h SendDataTask.c SendDataTask.h
  group User
    ../User/: main.c IRQHandler_Config.c 模板.txt ReadMe.txt
  group Communication
    ../Communication/: USART_Communication.c USART_Communication.h CAN_Communication.c CAN_Communication.h
  group BSP
    ../STM32/BSP/: RM_BSP.c RM_BSP.h CAN_Config.c CAN_Config.h Delay_Config.c Delay_Config.h WWDG_Config.c WWDG_Config.h USART_Config.c USART_Config.h TIM_Config.c TIM_Config.h
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/port/: heap_4.c port.c
    ../FreeRTOS/inc/: FreeRTOS.h FreeRTOSConfig.h
  group Driver/CMSIS
    ../STM32/Driver/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Driver/FWLiB
    ../STM32/Driver/FWLib/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ../STM32/Driver/FWLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../STM32/Driver/FWLib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2
